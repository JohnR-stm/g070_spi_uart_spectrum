# IAR project g070_spi_uart_spectrum.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32G070RB ST STM32G070RB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; STM32G0
  ICCARM.CCIncludePath2: ..\; ..\project; ..\project\modules\mdl_stm32; ..\project\modules\mdl_stm32\uart; ..\project\modules\mdl_stm32\led; ..\project\modules\mdl_stm32\spi; ..\project\mdl_config; ..\project\application; ..\project\ST; ..\project\ST\core; ..\project\ST\ll
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../project/: main.c
  group application
    ../project/application/: app_uart.c app_uart.h system_init.c system_init.h
  group config
    ../project/mdl_config/: led_config.h uart_config.h
  group modules/led
    ../project/modules/mdl_stm32/led/: led_hw.c led_hw.h
  group modules/spi
    ../project/modules/mdl_stm32/spi/: spi_hw.c spi_hw.h
  group modules/uart
    ../project/modules/mdl_stm32/uart/: uart.c uart.h uart_hw.c uart_hw.h
  group ST/CMSIS
    ../project/ST/core/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm0.h core_cm0plus.h mpu_armv7.h startup_stm32g070xx.s stm32g070xx.h stm32g0xx.h system_stm32g0xx.c system_stm32g0xx.h
  group ST/LL
    ../project/ST/ll/: stm32g0xx_ll_bus.h stm32g0xx_ll_cortex.h stm32g0xx_ll_crc.c stm32g0xx_ll_crc.h stm32g0xx_ll_dma.c stm32g0xx_ll_dma.h stm32g0xx_ll_dmamux.h stm32g0xx_ll_exti.c stm32g0xx_ll_exti.h stm32g0xx_ll_gpio.c stm32g0xx_ll_gpio.h stm32g0xx_ll_pwr.c stm32g0xx_ll_pwr.h stm32g0xx_ll_rcc.c stm32g0xx_ll_rcc.h stm32g0xx_ll_spi.c stm32g0xx_ll_spi.h stm32g0xx_ll_system.h stm32g0xx_ll_tim.c stm32g0xx_ll_tim.h stm32g0xx_ll_usart.c stm32g0xx_ll_usart.h stm32g0xx_ll_utils.c stm32g0xx_ll_utils.h
